# Keil uVision project Blinky.uvproj, settings and files
target STM32L100 RAM (ARM-ADS)
  device: STM32L100RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x1000
  group StartUp
    ./: startup_stm32l1xx_mdp.s system_stm32l1xx.c
  group Source Files
    ./: LED.c Blinky.c Retarget.c Serial.c uart.c
  group Documentation
    ./: Abstract.txt
  group LIBS
    ../STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_pwr.c stm32l1xx_usart.c misc.c
  group Modem
    ./: modem_test.c
  group GPS
    ./: gps_test.c
target STM32L100 Flash (ARM-ADS)
  device: STM32L100RC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: ..\STM32L1xx_StdPeriph_Driver\inc;..\CMSIS\Device\ST\STM32L1xx\Include;..\Blinky
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
